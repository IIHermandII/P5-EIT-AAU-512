options:
  parameters:
    generate_options: qt_gui
    id: Manual_phase_control
    output_language: python
    title: Manual phase control
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@0 : 0,0,1,1'
    rangeType: int
    start: int(2.4e9)
    step: int(1e6)
    stop: int(2.48e9)
    value: int(2.4e9)
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@0 : 1,0,1,1'
    rangeType: int
    start: '0'
    step: '1'
    stop: '80'
    value: '0'
  states: {}
- name: Phase_Delta
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@1 : 0,1,1,5'
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
  states: {}
- name: RX1
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tabs@1 : 1,0,1,1'
    type: real
    value: ((Phase_Delta*0+Rx1_Cal) % 360)
  states: {}
- name: RX2
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tabs@1 : 2,0,1,1'
    type: real
    value: ((Phase_Delta*1+Rx2_Cal) % 360)
  states: {}
- name: RX3
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tabs@1 : 3,0,1,1'
    type: real
    value: ((Phase_Delta*2+Rx3_Cal) % 360)
  states: {}
- name: RX4
  id: variable_qtgui_label
  parameters:
    gui_hint: 'Tabs@1 : 4,0,1,1'
    type: real
    value: ((Phase_Delta*3+Rx4_Cal) % 360)
  states: {}
- name: Rx1_Cal
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@1 : 1,1,1,5'
    start: '0'
    step: '1'
    stop: '360'
    value: '0'
  states: {}
- name: Rx2_Cal
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@1 : 2,1,1,5'
    start: '0'
    step: '1'
    stop: '360'
    value: '0'
  states: {}
- name: Rx3_Cal
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@1 : 3,1,1,5'
    start: '0'
    step: '1'
    stop: '360'
    value: '0'
  states: {}
- name: Rx4_Cal
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@1 : 4,1,1,5'
    start: '0'
    step: '1'
    stop: '360'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(5e6)
  states: {}
- name: Tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,1
    label0: RF control
    label1: Phase control
    num_tabs: '2'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    PhaseDelta: Phase_Delta
    Rx1_Phase_Cal: Rx1_Cal
    Rx2_Phase_Cal: Rx2_Cal + 31
    Rx3_Phase_Cal: Rx3_Cal + 355
    Rx4_Phase_Cal: Rx4_Cal + 20
    SignalFreq: Freq
    UpdateRate: '0.1'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      from ctypes import *
      import numpy as np
      from gnuradio import gr
      import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, UpdateRate = 1, PhaseDelta=45, SignalFreq=1, Rx1_Phase_Cal=0, Rx2_Phase_Cal=0, Rx3_Phase_Cal=0, Rx4_Phase_Cal=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Calculate Steering Angle',   # will show up in GRC
                  in_sig=[],   # we have no flowgraph inputs to this block
                  out_sig=[np.float32]   # we have one flowgraph output, which is the calculated steering angle
              )
              # this module will be imported in the into your flowgraph
              
              self.vnx = cdll.LoadLibrary(r"C:\Users\julm\Desktop\Drone detection\VNX_dps64.dll")
              self.vnx.fnLPS_SetTestMode(False)        # Use actual devices
              self.DeviceIDArray = c_int * 20
              self.Devices = self.DeviceIDArray()           # This array will hold the list of device handles returned by the DLL

              print('------- Initialize Lab Bricks -------')
              # GetNumDevices will determine how many LPS devices are availible
              self.numDevices = self.vnx.fnLPS_GetNumDevices()
              print(str(self.numDevices), ' device(s) found')

              # GetDevInfo generates a list, stored in the devices array, of
              # every availible LPS device attached to the system
              # GetDevInfo will return the number of device handles in the array
              dev_info = self.vnx.fnLPS_GetDevInfo(self.Devices)
              print('GetDevInfo returned', str(dev_info))
              self.ser_num = []
              # GetSerialNumber will return the devices serial number
              for i in range(self.numDevices):
                  self.ser_num.append(self.vnx.fnLPS_GetSerialNumber(self.Devices[i]))
                  print('Serial number:', str(self.ser_num[i]))

                  #InitDevice will prepare the device for operation
                  init_dev = self.vnx.fnLPS_InitDevice(self.Devices[i])
                  print('InitDevice returned', str(init_dev))
              print('---------- End initialize -----------')

              # print('----------- Device specs ------------')
              # # These functions will get the working frequency range of the LPS device
              # # and those frequencies will be turned into MHz
              # min_freq = self.vnx.fnLPS_GetMinWorkingFrequency(self.Devices[0])
              # max_freq = self.vnx.fnLPS_GetMaxWorkingFrequency(self.Devices[0])
              # min_working_freq_in_MHz = int(min_freq / 10)
              # max_working_freq_in_MHz = int(max_freq / 10)
              # print('Minimum working frequency for LPS device in MHz:', min_working_freq_in_MHz)
              # print('Maximum working frequency for LPS device in MHz:', max_working_freq_in_MHz)

              # # These functions get the minimum and maximum phase shift for the LPS device
              # max_angle = self.vnx.fnLPS_GetMaxPhaseShift(self.Devices[0])
              # min_angle = self.vnx.fnLPS_GetMinPhaseShift(self.Devices[0])
              # # This function gives the smallest increment by which the phase shift can be changed
              # min_step = self.vnx.fnLPS_GetMinPhaseStep(self.Devices[0])
              # print('Minimum phase shift that the Lab Brick is capable of, in degrees:', min_angle)
              # print('Maximum phase shift that the Lab Brick is capable of, in degrees:', max_angle)
              # print('Smallest phase shift increment that the Lab Brick is capable of, in degrees:', min_step)
              # print('------------- End specs -------------')
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.UpdateRate = UpdateRate
              self.PhaseDelta = PhaseDelta
              self.Rx1_Phase_Cal = Rx1_Phase_Cal
              self.Rx2_Phase_Cal = Rx2_Phase_Cal
              self.Rx3_Phase_Cal = Rx3_Phase_Cal
              self.Rx4_Phase_Cal = Rx4_Phase_Cal

              self.c = 3e8
              self.f = SignalFreq
              self.d = 1/2*(self.c/self.f)

              for i in range(self.numDevices):
                  result = self.vnx.fnLPS_SetWorkingFrequency(self.Devices[i], int(self.f/ 100000))
                  if result != 0:
                      print('SetFrequency returned', result)

          def work(self, input_items, output_items):
              # steering angle theta = arcsin(c*deltaphase/(2*pi*f*d)
              value1 = (self.c * np.radians(np.abs(self.PhaseDelta)))/(2*np.pi*self.f*self.d)
              clamped_value1 = max(min(1, value1), -1)     #arcsin argument must be between 1 and -1, or numpy will throw a warning
              theta = np.degrees(np.arcsin(clamped_value1))
              
              RxPhase1 = (self.PhaseDelta*0+self.Rx1_Phase_Cal) % 360
              RxPhase2 = (self.PhaseDelta*1+self.Rx2_Phase_Cal) % 360
              RxPhase3 = (self.PhaseDelta*2+self.Rx3_Phase_Cal) % 360
              RxPhase4 = (self.PhaseDelta*3+self.Rx4_Phase_Cal) % 360
              
              for i in range(self.numDevices):
                  match self.ser_num[i]:
                      case 24780:
                          result_1 = self.vnx.fnLPS_SetPhaseAngle(self.Devices[i], int(RxPhase1))
                          if result_1 != 0:
                              print('SetPhaseAngle returned error', result_1)
                      case 24781:
                          result_1 = self.vnx.fnLPS_SetPhaseAngle(self.Devices[i], int(RxPhase2))
                          if result_1 != 0:
                              print('SetPhaseAngle returned error', result_1)
                      case 24783:
                          result_1 = self.vnx.fnLPS_SetPhaseAngle(self.Devices[i], int(RxPhase3))
                          if result_1 != 0:
                              print('SetPhaseAngle returned error', result_1)
                      case 24784: 
                          result_1 = self.vnx.fnLPS_SetPhaseAngle(self.Devices[i], int(RxPhase4))
                          if result_1 != 0:
                              print('SetPhaseAngle returned error', result_1)
                      case _:
                          print("FUCK")

              if self.PhaseDelta>=0:
                  SteerAngle = 90-theta   # positive PhaseDelta covers 0deg to 90 deg
              else:
                  SteerAngle = 90+theta # negative phase delta covers 0 deg to -90 deg
              
              time.sleep(self.UpdateRate)

              output_items[0][:] = SteerAngle * (-1) + 90
              return len(output_items[0])
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,1
    max: '90'
    min: '-90'
    name: '"Steering angle"'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: int(2.44e9)
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: '"Measured data from SDR"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: Freq
    gain0: Gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
