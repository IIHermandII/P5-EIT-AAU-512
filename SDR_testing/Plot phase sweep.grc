options:
  parameters:
    generate_options: qt_gui
    id: Plot_phase_sweep
    output_language: python
    title: Phase sweeper
  states: {}

blocks:
- name: Freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@0 : 0,0,1,1'
    rangeType: int
    start: int(2.4e9)
    step: int(1e6)
    stop: int(2.48e9)
    value: int(2.4e9)
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@0 : 1,0,1,1'
    rangeType: int
    start: '0'
    step: '1'
    stop: '80'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(5e6)
  states: {}
- name: Tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: RF control
    num_tabs: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: samp_rate
    scale: 1/1000
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    Gain: Gain
    Rx1_Phase_Cal: '0'
    Rx2_Phase_Cal: '31'
    Rx3_Phase_Cal: '355'
    Rx4_Phase_Cal: '20'
    SampleRate: samp_rate
    SignalFreq: Freq
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nfrom ctypes import *\nimport numpy as np\nfrom gnuradio import gr\nimport uhd\nimport time \nimport serial\nimport pathlib\nimport os\n\"\"\"\nTO TRY:\n-Ny USB HUB / gav 1ms\n-Skrive til en enkelt enhed / stadig langsomt\n-Undersøge om der er et usb handle som fucker up - det virker jo til set frequency og så ikke til set phase - og phase er endda en mindre besked end frequency / PAS\n-Sende besked sammen med sæt working frequency / gav 10ms delay pr. besked\n-Sæt working frequency sammen i main loopet / 40ms delay - 10 pr enhed\n-Prøv at lade streamhandle ligge i Multi klassen og kun generere et nyt hvis det et None\n-Evt. skær ned på buffer for at det ikke tager længere tid end højst nødvendigt i Recv_num\n\"\"\"\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, SampleRate = 1, SignalFreq=1, Gain=1, Rx1_Phase_Cal=1, Rx2_Phase_Cal=1, Rx3_Phase_Cal=1, Rx4_Phase_Cal=1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Angle sweeper',  # will show up in GRC\n            in_sig=[],\n            out_sig=[np.complex64, np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.path = str(pathlib.Path().resolve())+\"\\VNX_dps64.dll\"\n        print(\"#####################path\")\n        print(self.path)\n        #r\"C:\\Users\\emill\\OneDrive - Aalborg Universitet\\GIT2\\P5-EIT-AAU-512\\SDR_testing\\VNX_dps64.dll\"\n        self.vnx = cdll.LoadLibrary(os.path.normpath(self.path)) # H phase shifter libery\n        self.vnx.fnLPS_SetTestMode(False)  # Use actual devices\n        self.DeviceIDArray = c_int * 20\n        self.Devices = self.DeviceIDArray()  # This array will hold the list of device handles returned by the DLL\n\n        print('------- Initialize Lab Bricks -------')\n        self.numDevices = self.vnx.fnLPS_GetNumDevices() # GetNumDevices will determine how many LPS devices are availible\n        print(str(self.numDevices), ' device(s) found')\n\n        # GetDevInfo generates a list, stored in the devices array, of\n        # every availible LPS device attached to the system\n        # GetDevInfo will return the number of device handles in the array\n        dev_info = self.vnx.fnLPS_GetDevInfo(self.Devices)\n        print('GetDevInfo returned', str(dev_info))\n        self.ser_num = []\n        # GetSerialNumber will return the devices serial number\n        for i in range(self.numDevices):\n            self.ser_num.append(self.vnx.fnLPS_GetSerialNumber(self.Devices[i]))\n            print('Serial number:', str(self.ser_num[i]))\n            init_dev = self.vnx.fnLPS_InitDevice(self.Devices[i])  #InitDevice will prepare the device for operation\n            print('InitDevice returned', str(init_dev))\n        print('---------- End initialize -----------')\n        \n        self.SampleRate = SampleRate #input\n        self.numSamples = 1024\n        self.Gain = Gain #input\n\n        self.c = 3e8\n        self.SignalFreq = SignalFreq #input\n        self.d = 1/2*(self.c/self.SignalFreq) # d = (1/2) * (3e8/2.4e9)\n\n        self.sdr = uhd.usrp.MultiUSRP(\"type=b200\")\n\n        self.Rx1_Phase_Cal = Rx1_Phase_Cal #phase off set\n        self.Rx2_Phase_Cal = Rx2_Phase_Cal #phase off set\n        self.Rx3_Phase_Cal = Rx3_Phase_Cal #phase off set\n        self.Rx4_Phase_Cal = Rx4_Phase_Cal #phase off set\n\n        self.PhaseStep = 4\n        self.PhaseValues = np.arange(-180, 184, self.PhaseStep) #finds number of steps\n\n        for i in range(self.numDevices):\n            #HER ER DER 2ms\n            #print(\"For loop\", time.time())\n            self.vnx.fnLPS_SetWorkingFrequency(self.Devices[i], int(self.SignalFreq/ 100000))\n        \n        self.lookUp = {}\n        \n        for i in range(self.numDevices):\n            match self.ser_num[i]:\n                case 24780:\n                    self.lookUp.update({0 : self.Devices[i]})\n                case 24781:\n                    self.lookUp.update({1 : self.Devices[i]})\n                case 24783:\n                    self.lookUp.update({2 : self.Devices[i]})  \n                case 24784: \n                    self.lookUp.update({3 : self.Devices[i]})\n        \n        #self.data = np.zeros((100),dtype=np.complex64)\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"        \n        max_signal = -10000\n        max_angle = 0\n\n        win = np.hamming(self.numSamples) #window function\n\n        PhaseStepNumber = 0 \n        tSweep = time.time()\n        \n\n        for PhDelta in self.PhaseValues: #evry tick in the -180 -> 184\n\n            # RxPhase1 = (PhDelta*0+self.Rx1_Phase_Cal) % 360\n            # RxPhase2 = (PhDelta*1+self.Rx2_Phase_Cal) % 360\n            # RxPhase3 = (PhDelta*2+self.Rx3_Phase_Cal) % 360\n            RxPhase4 = (PhDelta*3+self.Rx4_Phase_Cal) % 360 #the phase shift + offset % 360\n            # self.vnx.fnLPS_SetPhaseAngle(self.lookUp[0], int(RxPhase1))\n            # self.vnx.fnLPS_SetPhaseAngle(self.lookUp[1], int(RxPhase2))\n            # self.vnx.fnLPS_SetPhaseAngle(self.lookUp[2], int(RxPhase3))\n            tPhases = time.time()\n            self.vnx.fnLPS_SetPhaseAngle(self.lookUp[3], int(RxPhase4)) #phaseshifter, phase\n            # print(\"PHASESHIFTER USB time: \",(time.time()-tPhases)*1000, \"ms\")\n            \n            value1 = (self.c * np.radians(np.abs(PhDelta)))/(2*np.pi*self.SignalFreq*self.d) \n            clamped_value1 = max(min(1, value1), -1)     \n            theta = np.degrees(np.arcsin(clamped_value1))\n\n            error_func=0.0000002045*theta**4+0.00295*theta**2+2 #the theta does not macth theta irl for that error_func\n            theta -= error_func\n            if PhDelta>=0:\n                SteerAngle = theta   # positive PhaseDelta covers 0deg to 90 deg\n            else:\n                SteerAngle = -theta   # negative phase delta covers 0 deg to -90 deg\n\n            #print(\"Pre sample: \",time.time())\n\n            tSample = time.time()\n            #Get samples of data\n            data = self.sdr.recv_num_samps(\n            self.numSamples, # Number of samples\n            self.SignalFreq, # Frequency in Hz\n            self.SampleRate, # Sampling rate\n            [0], # Receive on channel 0\n            self.Gain, # dB of RX gain\n            )\n            \n            # print(\"SDR TOTAL Sample time: \",(time.time()-tSample)*1000, \"ms\")\n\n            y = data * win\n            sp = np.absolute(np.fft.fft(y,1024))\n            PeakValue = 20*np.log10(max(sp[0]))\n\n            if PeakValue > max_signal:\n                max_signal = PeakValue\n                max_angle = SteerAngle\n\n            output_items[0][PhaseStepNumber] = ((1)*SteerAngle + (1j * PeakValue))\n            PhaseStepNumber = PhaseStepNumber + 1\n                 \n        print(\"Sweep time: \",(time.time()-tSweep)*1000, \"ms\")  \n        #serial_arduino = serial.Serial('COM9',baudrate=115200,bytesize=8,parity='N',stopbits=1)\n        #serial_arduino.write(bytes(str(max_angle),'utf-8'))\n        output_items[0] = output_items[0][0:PhaseStepNumber]\n        output_items[1][:] = max_angle\n        return len(output_items[0])\n        "
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,0,1,1
    size: '91'
    type: complex
    xmax: '90'
    xmin: '-90'
    ymax: '10'
    ymin: '-50'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    max: '90'
    min: '-90'
    name: '"Max angle"'
    type: float
  states: {}

connections:
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_moving_average_xx_0, '0']
- [epy_block_1, '0', qtgui_const_sink_x_0, '0']
- [epy_block_1, '1', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
