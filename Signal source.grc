options:
  parameters:
    generate_options: qt_gui
    id: Signalsource
    output_language: python
    title: Signal source
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: 2.4e9
    step: 1e6
    stop: 2.4835e9
    value: 2.44e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    start: '0'
    step: '1'
    stop: '90'
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: toggle
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: toggle
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 200e3
    center_freq0: freq
    gain0: gain
    samp_rate: samp_rate
    stream_args: peak=0.003906
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
